// 5x7 bitmap font for printable ASCII (0x20..0x7E), Latin-1 (U+00A0..U+00FF) and Russian
// Cyrillic (U+0410..U+044F, Ё/ё),
// drawn as ASCII art so the glyphs are reviewable in a diff. '#' is an "on"
// pixel. Each entry is seven 5-character rows concatenated by the compiler.
#include "hg/font.hpp"

namespace hg::font {
namespace {

const char* const kGlyphs[95] = {
    // ' '
    "....." "....." "....." "....." "....." "....." ".....",
    // '!'
    "..#.." "..#.." "..#.." "..#.." "..#.." "....." "..#..",
    // '"'
    ".#.#." ".#.#." ".#.#." "....." "....." "....." ".....",
    // '#'
    ".#.#." ".#.#." "#####" ".#.#." "#####" ".#.#." ".#.#.",
    // '$'
    "..#.." ".####" "#.#.." ".###." "..#.#" "####." "..#..",
    // '%'
    "##..." "##..#" "...#." "..#.." ".#..." "#..##" "...##",
    // '&'
    ".##.." "#..#." "#.#.." ".#..." "#.#.#" "#..#." ".##.#",
    // '\''
    "..#.." "..#.." ".#..." "....." "....." "....." ".....",
    // '('
    "...#." "..#.." ".#..." ".#..." ".#..." "..#.." "...#.",
    // ')'
    ".#..." "..#.." "...#." "...#." "...#." "..#.." ".#...",
    // '*'
    "....." "..#.." "#.#.#" ".###." "#.#.#" "..#.." ".....",
    // '+'
    "....." "..#.." "..#.." "#####" "..#.." "..#.." ".....",
    // ','
    "....." "....." "....." "....." ".##.." "..#.." ".#...",
    // '-'
    "....." "....." "....." "#####" "....." "....." ".....",
    // '.'
    "....." "....." "....." "....." "....." ".##.." ".##..",
    // '/'
    "....." "....#" "...#." "..#.." ".#..." "#...." ".....",
    // '0'
    ".###." "#...#" "#..##" "#.#.#" "##..#" "#...#" ".###.",
    // '1'
    "..#.." ".##.." "..#.." "..#.." "..#.." "..#.." ".###.",
    // '2'
    ".###." "#...#" "....#" "...#." "..#.." ".#..." "#####",
    // '3'
    "#####" "...#." "..#.." "...#." "....#" "#...#" ".###.",
    // '4'
    "...#." "..##." ".#.#." "#..#." "#####" "...#." "...#.",
    // '5'
    "#####" "#...." "####." "....#" "....#" "#...#" ".###.",
    // '6'
    "..##." ".#..." "#...." "####." "#...#" "#...#" ".###.",
    // '7'
    "#####" "....#" "...#." "..#.." ".#..." ".#..." ".#...",
    // '8'
    ".###." "#...#" "#...#" ".###." "#...#" "#...#" ".###.",
    // '9'
    ".###." "#...#" "#...#" ".####" "....#" "...#." ".##..",
    // ':'
    "....." ".##.." ".##.." "....." ".##.." ".##.." ".....",
    // ';'
    "....." ".##.." ".##.." "....." ".##.." "..#.." ".#...",
    // '<'
    "...#." "..#.." ".#..." "#...." ".#..." "..#.." "...#.",
    // '='
    "....." "....." "#####" "....." "#####" "....." ".....",
    // '>'
    ".#..." "..#.." "...#." "....#" "...#." "..#.." ".#...",
    // '?'
    ".###." "#...#" "....#" "...#." "..#.." "....." "..#..",
    // '@'
    ".###." "#...#" "....#" ".##.#" "#.#.#" "#.#.#" ".###.",
    // 'A'
    ".###." "#...#" "#...#" "#####" "#...#" "#...#" "#...#",
    // 'B'
    "####." "#...#" "#...#" "####." "#...#" "#...#" "####.",
    // 'C'
    ".###." "#...#" "#...." "#...." "#...." "#...#" ".###.",
    // 'D'
    "###.." "#..#." "#...#" "#...#" "#...#" "#..#." "###..",
    // 'E'
    "#####" "#...." "#...." "####." "#...." "#...." "#####",
    // 'F'
    "#####" "#...." "#...." "####." "#...." "#...." "#....",
    // 'G'
    ".###." "#...#" "#...." "#.###" "#...#" "#...#" ".####",
    // 'H'
    "#...#" "#...#" "#...#" "#####" "#...#" "#...#" "#...#",
    // 'I'
    ".###." "..#.." "..#.." "..#.." "..#.." "..#.." ".###.",
    // 'J'
    "..###" "...#." "...#." "...#." "...#." "#..#." ".##..",
    // 'K'
    "#...#" "#..#." "#.#.." "##..." "#.#.." "#..#." "#...#",
    // 'L'
    "#...." "#...." "#...." "#...." "#...." "#...." "#####",
    // 'M'
    "#...#" "##.##" "#.#.#" "#.#.#" "#...#" "#...#" "#...#",
    // 'N'
    "#...#" "#...#" "##..#" "#.#.#" "#..##" "#...#" "#...#",
    // 'O'
    ".###." "#...#" "#...#" "#...#" "#...#" "#...#" ".###.",
    // 'P'
    "####." "#...#" "#...#" "####." "#...." "#...." "#....",
    // 'Q'
    ".###." "#...#" "#...#" "#...#" "#.#.#" "#..#." ".##.#",
    // 'R'
    "####." "#...#" "#...#" "####." "#.#.." "#..#." "#...#",
    // 'S'
    ".####" "#...." "#...." ".###." "....#" "....#" "####.",
    // 'T'
    "#####" "..#.." "..#.." "..#.." "..#.." "..#.." "..#..",
    // 'U'
    "#...#" "#...#" "#...#" "#...#" "#...#" "#...#" ".###.",
    // 'V'
    "#...#" "#...#" "#...#" "#...#" "#...#" ".#.#." "..#..",
    // 'W'
    "#...#" "#...#" "#...#" "#.#.#" "#.#.#" "#.#.#" ".#.#.",
    // 'X'
    "#...#" "#...#" ".#.#." "..#.." ".#.#." "#...#" "#...#",
    // 'Y'
    "#...#" "#...#" "#...#" ".#.#." "..#.." "..#.." "..#..",
    // 'Z'
    "#####" "....#" "...#." "..#.." ".#..." "#...." "#####",
    // '['
    ".###." ".#..." ".#..." ".#..." ".#..." ".#..." ".###.",
    // '\\'
    "....." "#...." ".#..." "..#.." "...#." "....#" ".....",
    // ']'
    ".###." "...#." "...#." "...#." "...#." "...#." ".###.",
    // '^'
    "..#.." ".#.#." "#...#" "....." "....." "....." ".....",
    // '_'
    "....." "....." "....." "....." "....." "....." "#####",
    // '`'
    ".#..." "..#.." "...#." "....." "....." "....." ".....",
    // 'a'
    "....." "....." ".###." "....#" ".####" "#...#" ".####",
    // 'b'
    "#...." "#...." "#.##." "##..#" "#...#" "#...#" "####.",
    // 'c'
    "....." "....." ".###." "#...." "#...." "#...#" ".###.",
    // 'd'
    "....#" "....#" ".##.#" "#..##" "#...#" "#...#" ".####",
    // 'e'
    "....." "....." ".###." "#...#" "#####" "#...." ".###.",
    // 'f'
    "..##." ".#..#" ".#..." "###.." ".#..." ".#..." ".#...",
    // 'g'
    "....." ".####" "#...#" "#...#" ".####" "....#" ".###.",
    // 'h'
    "#...." "#...." "#.##." "##..#" "#...#" "#...#" "#...#",
    // 'i'
    "..#.." "....." ".##.." "..#.." "..#.." "..#.." ".###.",
    // 'j'
    "...#." "....." "..##." "...#." "...#." "#..#." ".##..",
    // 'k'
    "#...." "#...." "#..#." "#.#.." "##..." "#.#.." "#..#.",
    // 'l'
    ".##.." "..#.." "..#.." "..#.." "..#.." "..#.." ".###.",
    // 'm'
    "....." "....." "##.#." "#.#.#" "#.#.#" "#...#" "#...#",
    // 'n'
    "....." "....." "#.##." "##..#" "#...#" "#...#" "#...#",
    // 'o'
    "....." "....." ".###." "#...#" "#...#" "#...#" ".###.",
    // 'p'
    "....." "....." "####." "#...#" "####." "#...." "#....",
    // 'q'
    "....." "....." ".####" "#...#" ".####" "....#" "....#",
    // 'r'
    "....." "....." "#.##." "##..#" "#...." "#...." "#....",
    // 's'
    "....." "....." ".####" "#...." ".###." "....#" "####.",
    // 't'
    ".#..." ".#..." "###.." ".#..." ".#..." ".#..#" "..##.",
    // 'u'
    "....." "....." "#...#" "#...#" "#...#" "#..##" ".##.#",
    // 'v'
    "....." "....." "#...#" "#...#" "#...#" ".#.#." "..#..",
    // 'w'
    "....." "....." "#...#" "#...#" "#.#.#" "#.#.#" ".#.#.",
    // 'x'
    "....." "....." "#...#" ".#.#." "..#.." ".#.#." "#...#",
    // 'y'
    "....." "....." "#...#" "#...#" ".####" "....#" ".###.",
    // 'z'
    "....." "....." "#####" "...#." "..#.." ".#..." "#####",
    // '{'
    "...#." "..#.." "..#.." ".#..." "..#.." "..#.." "...#.",
    // '|'
    "..#.." "..#.." "..#.." "..#.." "..#.." "..#.." "..#..",
    // '}'
    ".#..." "..#.." "..#.." "...#." "..#.." "..#.." ".#...",
    // '~'
    "....." "....." ".#..." "#.#.#" "...#." "....." ".....",
};

// Latin-1. An accented capital is the five-row form of its letter under a
// two-row accent; a small letter is four rows under the accent and a blank row.
const char* const kLatin1[96] = {
    // U+00A0 no-break space
    "....." "....." "....." "....." "....." "....." ".....",
    // U+00A1 ¡
    "..#.." "....." "..#.." "..#.." "..#.." "..#.." "..#..",
    // U+00A2 ¢
    "..#.." ".####" "#.#.." "#.#.." "#.#.." ".####" "..#..",
    // U+00A3 £
    "..##." ".#..#" ".#..." "###.." ".#..." ".#..#" "#.##.",
    // U+00A4 ¤
    "....." "#...#" ".###." ".#.#." ".###." "#...#" ".....",
    // U+00A5 ¥
    "#...#" ".#.#." "#####" "..#.." "#####" "..#.." "..#..",
    // U+00A6 ¦
    "..#.." "..#.." "..#.." "....." "..#.." "..#.." "..#..",
    // U+00A7 §
    ".###." "#...." ".##.." "#..#." ".##.." "...#." "###..",
    // U+00A8 ¨
    ".#.#." "....." "....." "....." "....." "....." ".....",
    // U+00A9 ©
    ".###." "#...#" "#.#.#" "##..#" "#.#.#" "#...#" ".###.",
    // U+00AA ª
    ".##.." "...#." ".###." "#..#." ".###." "....." "####.",
    // U+00AB «
    "....." "..#.#" ".#.#." "#.#.." ".#.#." "..#.#" ".....",
    // U+00AC ¬
    "....." "....." "#####" "....#" "....#" "....." ".....",
    // U+00AD soft hyphen
    "....." "....." "....." ".###." "....." "....." ".....",
    // U+00AE ®
    ".###." "#...#" "###.#" "##.##" "###.#" "#.#.#" ".###.",
    // U+00AF ¯
    "#####" "....." "....." "....." "....." "....." ".....",
    // U+00B0 °
    ".##.." "#..#." ".##.." "....." "....." "....." ".....",
    // U+00B1 ±
    "..#.." "..#.." "#####" "..#.." "..#.." "....." "#####",
    // U+00B2 ²
    ".##.." "...#." "..#.." ".###." "....." "....." ".....",
    // U+00B3 ³
    ".##.." "..##." "...#." ".##.." "....." "....." ".....",
    // U+00B4 ´
    "...#." "..#.." "....." "....." "....." "....." ".....",
    // U+00B5 µ
    "....." "....." "#..#." "#..#." "#..#." "###.#" "#....",
    // U+00B6 ¶
    ".####" "###.#" "###.#" ".##.#" "..#.#" "..#.#" "..#.#",
    // U+00B7 ·
    "....." "....." "....." "..#.." "....." "....." ".....",
    // U+00B8 ¸
    "....." "....." "....." "....." "....." "..#.." ".##..",
    // U+00B9 ¹
    "..#.." ".##.." "..#.." ".###." "....." "....." ".....",
    // U+00BA º
    ".##.." "#..#." "#..#." ".##.." "....." "####." ".....",
    // U+00BB »
    "....." "#.#.." ".#.#." "..#.#" ".#.#." "#.#.." ".....",
    // U+00BC ¼
    "#...#" "#..#." "#.#.." ".#.#." "#.##." "..###" "...#.",
    // U+00BD ½
    "#...#" "#..#." "#.#.." ".#.##" "#...#" "...#." "..###",
    // U+00BE ¾
    "##..#" ".##.." "##.#." ".#.#." "#.##." "..###" "...#.",
    // U+00BF ¿
    "..#.." "....." "..#.." ".#..." "#...." "#...#" ".###.",
    // U+00C0 À
    ".#..." "..#.." ".###." "#...#" "#####" "#...#" "#...#",
    // U+00C1 Á
    "...#." "..#.." ".###." "#...#" "#####" "#...#" "#...#",
    // U+00C2 Â
    "..#.." ".#.#." ".###." "#...#" "#####" "#...#" "#...#",
    // U+00C3 Ã
    ".#..#" "#.##." ".###." "#...#" "#####" "#...#" "#...#",
    // U+00C4 Ä
    ".#.#." "....." ".###." "#...#" "#####" "#...#" "#...#",
    // U+00C5 Å
    ".###." ".#.#." ".###." "#...#" "#####" "#...#" "#...#",
    // U+00C6 Æ
    ".####" "#.#.." "#.#.." "####." "#.#.." "#.#.." "#.###",
    // U+00C7 Ç
    ".###." "#...#" "#...." "#...#" ".###." "..#.." ".##..",
    // U+00C8 È
    ".#..." "..#.." "#####" "#...." "####." "#...." "#####",
    // U+00C9 É
    "...#." "..#.." "#####" "#...." "####." "#...." "#####",
    // U+00CA Ê
    "..#.." ".#.#." "#####" "#...." "####." "#...." "#####",
    // U+00CB Ë
    ".#.#." "....." "#####" "#...." "####." "#...." "#####",
    // U+00CC Ì
    ".#..." "..#.." ".###." "..#.." "..#.." "..#.." ".###.",
    // U+00CD Í
    "...#." "..#.." ".###." "..#.." "..#.." "..#.." ".###.",
    // U+00CE Î
    "..#.." ".#.#." ".###." "..#.." "..#.." "..#.." ".###.",
    // U+00CF Ï
    ".#.#." "....." ".###." "..#.." "..#.." "..#.." ".###.",
    // U+00D0 Ð
    "###.." "#..#." "#...#" "###.#" "#...#" "#..#." "###..",
    // U+00D1 Ñ
    ".#..#" "#.##." "#...#" "##..#" "#.#.#" "#..##" "#...#",
    // U+00D2 Ò
    ".#..." "..#.." ".###." "#...#" "#...#" "#...#" ".###.",
    // U+00D3 Ó
    "...#." "..#.." ".###." "#...#" "#...#" "#...#" ".###.",
    // U+00D4 Ô
    "..#.." ".#.#." ".###." "#...#" "#...#" "#...#" ".###.",
    // U+00D5 Õ
    ".#..#" "#.##." ".###." "#...#" "#...#" "#...#" ".###.",
    // U+00D6 Ö
    ".#.#." "....." ".###." "#...#" "#...#" "#...#" ".###.",
    // U+00D7 ×
    "....." "#...#" ".#.#." "..#.." ".#.#." "#...#" ".....",
    // U+00D8 Ø
    ".###." "#..##" "#.#.#" "#.#.#" "#.#.#" "##..#" ".###.",
    // U+00D9 Ù
    ".#..." "..#.." "#...#" "#...#" "#...#" "#...#" ".###.",
    // U+00DA Ú
    "...#." "..#.." "#...#" "#...#" "#...#" "#...#" ".###.",
    // U+00DB Û
    "..#.." ".#.#." "#...#" "#...#" "#...#" "#...#" ".###.",
    // U+00DC Ü
    ".#.#." "....." "#...#" "#...#" "#...#" "#...#" ".###.",
    // U+00DD Ý
    "...#." "..#.." "#...#" ".#.#." "..#.." "..#.." "..#..",
    // U+00DE Þ
    "#...." "####." "#...#" "#...#" "####." "#...." "#....",
    // U+00DF ß
    ".##.." "#..#." "#..#." "#.##." "#...#" "#...#" "#.##.",
    // U+00E0 à
    ".#..." "..#.." "....." ".###." ".####" "#...#" ".####",
    // U+00E1 á
    "...#." "..#.." "....." ".###." ".####" "#...#" ".####",
    // U+00E2 â
    "..#.." ".#.#." "....." ".###." ".####" "#...#" ".####",
    // U+00E3 ã
    ".#..#" "#.##." "....." ".###." ".####" "#...#" ".####",
    // U+00E4 ä
    ".#.#." "....." "....." ".###." ".####" "#...#" ".####",
    // U+00E5 å
    ".###." ".#.#." "....." ".###." ".####" "#...#" ".####",
    // U+00E6 æ
    "....." "....." "##.#." "..#.#" ".####" "#.#.." ".#.##",
    // U+00E7 ç
    "....." ".###." "#...." "#...." ".###." "..#.." ".##..",
    // U+00E8 è
    ".#..." "..#.." "....." ".###." "#####" "#...." ".###.",
    // U+00E9 é
    "...#." "..#.." "....." ".###." "#####" "#...." ".###.",
    // U+00EA ê
    "..#.." ".#.#." "....." ".###." "#####" "#...." ".###.",
    // U+00EB ë
    ".#.#." "....." "....." ".###." "#####" "#...." ".###.",
    // U+00EC ì
    ".#..." "..#.." "....." ".##.." "..#.." "..#.." ".###.",
    // U+00ED í
    "...#." "..#.." "....." ".##.." "..#.." "..#.." ".###.",
    // U+00EE î
    "..#.." ".#.#." "....." ".##.." "..#.." "..#.." ".###.",
    // U+00EF ï
    ".#.#." "....." "....." ".##.." "..#.." "..#.." ".###.",
    // U+00F0 ð
    ".#.#." "..#.." ".#.#." ".###." "#...#" "#...#" ".###.",
    // U+00F1 ñ
    ".#..#" "#.##." "....." "####." "#...#" "#...#" "#...#",
    // U+00F2 ò
    ".#..." "..#.." "....." ".###." "#...#" "#...#" ".###.",
    // U+00F3 ó
    "...#." "..#.." "....." ".###." "#...#" "#...#" ".###.",
    // U+00F4 ô
    "..#.." ".#.#." "....." ".###." "#...#" "#...#" ".###.",
    // U+00F5 õ
    ".#..#" "#.##." "....." ".###." "#...#" "#...#" ".###.",
    // U+00F6 ö
    ".#.#." "....." "....." ".###." "#...#" "#...#" ".###.",
    // U+00F7 ÷
    "....." "..#.." "....." "#####" "....." "..#.." ".....",
    // U+00F8 ø
    "....." "....." ".###." "#..##" "#.#.#" "##..#" ".###.",
    // U+00F9 ù
    ".#..." "..#.." "....." "#...#" "#...#" "#..##" ".##.#",
    // U+00FA ú
    "...#." "..#.." "....." "#...#" "#...#" "#..##" ".##.#",
    // U+00FB û
    "..#.." ".#.#." "....." "#...#" "#...#" "#..##" ".##.#",
    // U+00FC ü
    ".#.#." "....." "....." "#...#" "#...#" "#..##" ".##.#",
    // U+00FD ý
    "...#." "..#.." "#...#" "#...#" ".####" "....#" ".###.",
    // U+00FE þ
    "....." "#...." "####." "#...#" "####." "#...." "#....",
    // U+00FF ÿ
    ".#.#." "....." "#...#" "#...#" ".####" "....#" ".###.",
};

// Cyrillic U+0410..U+044F (А..я), same 5x7 grid; letters identical to Latin ones reuse them.
const char* const kCyrillic[64] = {
    // U+0410 А
    ".###." "#...#" "#...#" "#####" "#...#" "#...#" "#...#",
    // U+0411 Б
    "#####" "#...." "#...." "####." "#...#" "#...#" "####.",
    // U+0412 В
    "####." "#...#" "#...#" "####." "#...#" "#...#" "####.",
    // U+0413 Г
    "#####" "#...." "#...." "#...." "#...." "#...." "#....",
    // U+0414 Д
    ".###." ".#.#." ".#.#." ".#.#." ".#.#." "#####" "#...#",
    // U+0415 Е
    "#####" "#...." "#...." "####." "#...." "#...." "#####",
    // U+0416 Ж
    "#.#.#" "#.#.#" ".###." "..#.." ".###." "#.#.#" "#.#.#",
    // U+0417 З
    ".###." "#...#" "....#" "..##." "....#" "#...#" ".###.",
    // U+0418 И
    "#...#" "#...#" "#..##" "#.#.#" "##..#" "#...#" "#...#",
    // U+0419 Й
    ".###." "#...#" "#..##" "#.#.#" "##..#" "#...#" "#...#",
    // U+041A К
    "#...#" "#..#." "#.#.." "##..." "#.#.." "#..#." "#...#",
    // U+041B Л
    "..###" ".#..#" ".#..#" ".#..#" ".#..#" ".#..#" "#...#",
    // U+041C М
    "#...#" "##.##" "#.#.#" "#.#.#" "#...#" "#...#" "#...#",
    // U+041D Н
    "#...#" "#...#" "#...#" "#####" "#...#" "#...#" "#...#",
    // U+041E О
    ".###." "#...#" "#...#" "#...#" "#...#" "#...#" ".###.",
    // U+041F П
    "#####" "#...#" "#...#" "#...#" "#...#" "#...#" "#...#",
    // U+0420 Р
    "####." "#...#" "#...#" "####." "#...." "#...." "#....",
    // U+0421 С
    ".###." "#...#" "#...." "#...." "#...." "#...#" ".###.",
    // U+0422 Т
    "#####" "..#.." "..#.." "..#.." "..#.." "..#.." "..#..",
    // U+0423 У
    "#...#" "#...#" "#...#" ".####" "....#" "#...#" ".###.",
    // U+0424 Ф
    "..#.." ".###." "#.#.#" "#.#.#" "#.#.#" ".###." "..#..",
    // U+0425 Х
    "#...#" "#...#" ".#.#." "..#.." ".#.#." "#...#" "#...#",
    // U+0426 Ц
    "#..#." "#..#." "#..#." "#..#." "#..#." "#####" "....#",
    // U+0427 Ч
    "#...#" "#...#" "#...#" ".####" "....#" "....#" "....#",
    // U+0428 Ш
    "#.#.#" "#.#.#" "#.#.#" "#.#.#" "#.#.#" "#.#.#" "#####",
    // U+0429 Щ
    "#.#.#" "#.#.#" "#.#.#" "#.#.#" "#.#.#" "#####" "....#",
    // U+042A Ъ
    "##..." ".#..." ".#..." ".###." ".#..#" ".#..#" ".###.",
    // U+042B Ы
    "#...#" "#...#" "#...#" "##..#" "#.#.#" "#.#.#" "##..#",
    // U+042C Ь
    "#...." "#...." "#...." "####." "#...#" "#...#" "####.",
    // U+042D Э
    ".###." "#...#" "....#" ".####" "....#" "#...#" ".###.",
    // U+042E Ю
    "#..#." "#.#.#" "#.#.#" "###.#" "#.#.#" "#.#.#" "#..#.",
    // U+042F Я
    ".####" "#...#" "#...#" ".####" "..#.#" ".#..#" "#...#",
    // U+0430 а
    "....." "....." ".###." "....#" ".####" "#...#" ".####",
    // U+0431 б
    "...##" ".##.." "#...." "####." "#...#" "#...#" ".###.",
    // U+0432 в
    "....." "....." "####." "#...#" "####." "#...#" "####.",
    // U+0433 г
    "....." "....." "#####" "#...." "#...." "#...." "#....",
    // U+0434 д
    "....." "....." ".###." ".#.#." ".#.#." "#####" "#...#",
    // U+0435 е
    "....." "....." ".###." "#...#" "#####" "#...." ".###.",
    // U+0436 ж
    "....." "....." "#.#.#" ".###." "..#.." ".###." "#.#.#",
    // U+0437 з
    "....." "....." "####." "....#" ".###." "....#" "####.",
    // U+0438 и
    "....." "....." "#...#" "#..##" "#.#.#" "##..#" "#...#",
    // U+0439 й
    ".#.#." "..#.." "#...#" "#..##" "#.#.#" "##..#" "#...#",
    // U+043A к
    "....." "....." "#..#." "#.#.." "##..." "#.#.." "#..#.",
    // U+043B л
    "....." "....." "..###" ".#..#" ".#..#" ".#..#" "#...#",
    // U+043C м
    "....." "....." "#...#" "##.##" "#.#.#" "#...#" "#...#",
    // U+043D н
    "....." "....." "#...#" "#...#" "#####" "#...#" "#...#",
    // U+043E о
    "....." "....." ".###." "#...#" "#...#" "#...#" ".###.",
    // U+043F п
    "....." "....." "#####" "#...#" "#...#" "#...#" "#...#",
    // U+0440 р
    "....." "....." "####." "#...#" "####." "#...." "#....",
    // U+0441 с
    "....." "....." ".###." "#...." "#...." "#...#" ".###.",
    // U+0442 т
    "....." "....." "#####" "..#.." "..#.." "..#.." "..#..",
    // U+0443 у
    "....." "....." "#...#" "#...#" ".####" "....#" ".###.",
    // U+0444 ф
    "....." "..#.." ".###." "#.#.#" "#.#.#" ".###." "..#..",
    // U+0445 х
    "....." "....." "#...#" ".#.#." "..#.." ".#.#." "#...#",
    // U+0446 ц
    "....." "....." "#..#." "#..#." "#..#." "#####" "....#",
    // U+0447 ч
    "....." "....." "#...#" "#...#" ".####" "....#" "....#",
    // U+0448 ш
    "....." "....." "#.#.#" "#.#.#" "#.#.#" "#.#.#" "#####",
    // U+0449 щ
    "....." "....." "#.#.#" "#.#.#" "#.#.#" "#####" "....#",
    // U+044A ъ
    "....." "....." "##..." ".#..." ".###." ".#..#" ".###.",
    // U+044B ы
    "....." "....." "#...#" "#...#" "##..#" "#.#.#" "##..#",
    // U+044C ь
    "....." "....." "#...." "#...." "####." "#...#" "####.",
    // U+044D э
    "....." "....." ".###." "....#" ".####" "....#" ".###.",
    // U+044E ю
    "....." "....." "#..#." "#.#.#" "###.#" "#.#.#" "#..#.",
    // U+044F я
    "....." "....." ".####" "#...#" ".####" ".#..#" "#...#",
};
// U+0401 Ё, U+0451 ё
const char* const kYo[2] = {
    ".#.#." "....." "#####" "#...." "####." "#...." "#####",
    ".#.#." "....." ".###." "#...#" "#####" "#...." ".###.",
};

}  // namespace

bool drawable(char32_t cp) {
  return (cp >= 0x20 && cp <= 0x7E) || (cp >= 0xA0 && cp <= 0xFF) || (cp >= 0x410 && cp <= 0x44F) ||
         cp == 0x401 || cp == 0x451 || cjk_glyph(cp) != nullptr;
}

const char* glyph(char32_t cp) {
  if (cp >= 0x20 && cp <= 0x7E) return kGlyphs[cp - 0x20];
  if (cp >= 0xA0 && cp <= 0xFF) return kLatin1[cp - 0xA0];
  if (cp >= 0x410 && cp <= 0x44F) return kCyrillic[cp - 0x410];
  if (cp == 0x401) return kYo[0];
  if (cp == 0x451) return kYo[1];
  return kGlyphs['?' - 0x20];
}

char32_t next(std::string_view s, size_t& i) {
  const unsigned char c = static_cast<unsigned char>(s[i]);
  if (c < 0x80) {
    ++i;
    return c;
  }
  const size_t len = c >= 0xF0 ? 4 : c >= 0xE0 ? 3 : c >= 0xC2 ? 2 : 0;
  char32_t cp = len == 4 ? c & 0x07u : len == 3 ? c & 0x0Fu : c & 0x1Fu;
  bool ok = len > 0 && i + len <= s.size();
  for (size_t k = 1; ok && k < len; ++k) {
    const unsigned char cc = static_cast<unsigned char>(s[i + k]);
    if ((cc & 0xC0) != 0x80) ok = false;
    cp = (cp << 6) | (cc & 0x3Fu);
  }
  if (!ok) {
    ++i;
    return 0xFFFD;
  }
  i += len;
  return cp;
}

size_t length(std::string_view s) {
  size_t n = 0;
  for (size_t i = 0; i < s.size();) n += static_cast<size_t>(columns(next(s, i)));
  return n;
}

size_t prefix(std::string_view s, size_t chars) {
  size_t i = 0, used = 0;
  while (i < s.size()) {
    const size_t start = i;
    const size_t w = static_cast<size_t>(columns(next(s, i)));
    if (used + w > chars) return start;
    used += w;
  }
  return i;
}

}  // namespace hg::font
